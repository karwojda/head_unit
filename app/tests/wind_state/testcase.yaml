## app/tests/wind_state/testcase.yaml
```yaml
tests:
  head_unit.wind_state:
    platform_allow:
      - native_sim/native/64
    integration_platforms:
      - native_sim/native/64
```
